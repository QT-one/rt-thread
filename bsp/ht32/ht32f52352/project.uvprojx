# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: HT32F52352 Holtek
  pack: Holtek.HT32_DFP.1.0.19
  cpu: IRAM(0x20000000,0x4000) IROM(0x00000000,0x1FE00) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: rt-thread
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __STDC_LIMIT_MACROS, __CLK_TCK=RT_TICK_PER_SECOND, __RTTHREAD__, RT_USING_ARMLIBC, RT_USING_LIBC, USE_HT32F52352_SK, USE_HT32F52342_52, USE_MEM_HT32F52352, USE_HT32_DRIVER
  c include: ..\..\..\components\libc\compilers\common\extension\fcntl\octal;..\libraries\ht32_drivers;..\..\..\components\libc\compilers\common\include;.;..\..\..\components\libc\posix\io\eventfd;..\..\..\components\drivers\include;..\..\..\components\libc\compilers\common\extension;..\..\..\components\libc\posix\io\epoll;..\..\..\include;..\libraries\HT32_STD_5xxxx_FWLib\library\HT32F5xxxx_Driver\inc;..\..\..\components\drivers\spi;..\..\..\components\drivers\include;..\libraries\HT32_STD_5xxxx_FWLib\library\Device\Holtek\HT32F5xxxx\Include;..\..\..\libcpu\arm\cortex-m0;applications;board\inc;..\..\..\components\drivers\include;..\..\..\components\finsh;..\..\..\components\drivers\include;..\..\..\libcpu\arm\common;..\libraries\HT32_STD_5xxxx_FWLib\library\CMSIS\Include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\libc\posix\ipc;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\libc\posix\io\poll
  asm define: USE_HT32_CHIP=4
  memory RVCT4: ROM 0x0 size 0x1fe00
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c
  group Compiler
    ../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group DeviceDrivers
    ../../../components/drivers/core/: device.c
    ../../../components/drivers/i2c/: i2c-bit-ops.c i2c_core.c i2c_dev.c
    ../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/misc/: adc.c
    ../../../components/drivers/pin/: pin.c
    ../../../components/drivers/serial/: serial.c
    ../../../components/drivers/spi/: spi_core.c spi_dev.c
    ../../../components/drivers/watchdog/: watchdog.c
  group Drivers
    board/src/: board.c ht32_msp.c
    ../libraries/HT32_STD_5xxxx_FWLib/library/Device/Holtek/HT32F5xxxx/Source/ARM/: startup_ht32f5xxxx_01.s
    ../libraries/ht32_drivers/: drv_common.c drv_gpio.c drv_usart.c
  group Finsh
    ../../../components/finsh/: msh_parse.c shell.c cmd.c msh.c
  group Kernel
    ../../../src/: clock.c components.c cpu_up.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
    ../../../src/klibc/: kstdio.c kstring.c
  group libcpu
    ../../../libcpu/arm/common/: div0.c showmem.c
    ../../../libcpu/arm/cortex-m0/: context_rvds.S cpuport.c
  group Libraries
    ../libraries/HT32_STD_5xxxx_FWLib/library/HT32F5xxxx_Driver/src/: ht32f5xxxx_sci.c ht32f5xxxx_rtc.c ht32f5xxxx_flash.c ht32f5xxxx_tm.c ht32f5xxxx_cmp.c ht32f5xxxx_i2s.c ht32f5xxxx_rstcu.c ht32f5xxxx_ebi.c ht32f5xxxx_pdma.c ht32f5xxxx_usart.c ht32f5xxxx_pwrcu.c ht32f5xxxx_spi.c ht32f5xxxx_crc.c ht32f5xxxx_ckcu.c ht32f5xxxx_adc.c ht32f5xxxx_usbd.c ht32f5xxxx_bftm.c ht32f5xxxx_i2c.c ht32_cm0plus_misc.c ht32f5xxxx_mctm.c ht32f5xxxx_exti.c ht32f5xxxx_gpio.c ht32f5xxxx_wdt.c
    ../libraries/HT32_STD_5xxxx_FWLib/library/Device/Holtek/HT32F5xxxx/Source/: system_ht32f5xxxx_01.c
