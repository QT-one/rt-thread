# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: HT32F12366 Holtek
  pack: Holtek.HT32_DFP.1.0.55
  cpu: IRAM(0x20000000,0x20000) IROM(0x00000000,0x3FC00) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: rt-thread
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: RT_USING_LIBC, USE_HT32_DRIVER, __CLK_TCK=RT_TICK_PER_SECOND, RT_USING_ARMLIBC, __RTTHREAD__, USE_HT32F12366_SK, USE_HT32F12365_66, USE_MEM_HT32F12366, __STDC_LIMIT_MACROS
  c misc: --gnu
  c include: ..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\libc\compilers\common\extension;..\..\..\components\drivers\spi;..\libraries\usbd_library\inc;.;..\..\..\components\libc\posix\io\eventfd;applications;..\..\..\components\drivers\include;..\..\..\components\libc\posix\io\poll;..\..\..\components\libc\compilers\common\extension\fcntl\octal;..\..\..\components\drivers\include;..\..\..\include;..\libraries\ht32_drivers;..\..\..\components\libc\posix\ipc;..\..\..\components\drivers\include;..\libraries\HT32_STD_1xxxx_FWLib\library\Device\Holtek\HT32F1xxxx\Include;..\..\..\components\drivers\include;board\inc;..\..\..\libcpu\arm\common;..\..\..\components\drivers\include;..\..\..\components\libc\compilers\common\include;..\..\..\libcpu\arm\cortex-m3;..\libraries\HT32_STD_1xxxx_FWLib\library\HT32F1xxxx_Driver\inc;..\..\..\components\finsh;..\..\..\components\drivers\include;..\..\..\components\libc\posix\io\epoll;..\libraries\HT32_STD_1xxxx_FWLib\library\CMSIS\Include;..\..\..\components\drivers\include
  asm define: USE_HT32_CHIP=2
  memory RVCT4: ROM 0x0 size 0x3fc00
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: test.c main.c
  group Compiler
    ../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group DeviceDrivers
    ../../../components/drivers/core/: device.c
    ../../../components/drivers/i2c/: i2c-bit-ops.c i2c_core.c i2c_dev.c
    ../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/misc/: adc.c
    ../../../components/drivers/pin/: pin.c
    ../../../components/drivers/sdio/: block_dev.c gpt.c mmc.c mmcsd_core.c sd.c sdio.c
    ../../../components/drivers/serial/: serial.c
    ../../../components/drivers/spi/: spi_core.c spi_dev.c
    ../../../components/drivers/watchdog/: watchdog.c
  group Drivers
    board/src/: board.c ht32_msp.c
    ../libraries/HT32_STD_1xxxx_FWLib/library/Device/Holtek/HT32F1xxxx/Source/ARM/: startup_ht32f1xxxx_01.s
    ../libraries/ht32_drivers/: drv_common.c drv_gpio.c drv_sdio.c drv_usart.c
  group Finsh
    ../../../components/finsh/: msh.c cmd.c shell.c msh_parse.c
  group Kernel
    ../../../src/: clock.c components.c cpu_up.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
    ../../../src/klibc/: kstdio.c kstring.c
  group libcpu
    ../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../libcpu/arm/cortex-m3/: context_rvds.S cpuport.c
  group Libraries
    ../libraries/HT32_STD_1xxxx_FWLib/library/HT32F1xxxx_Driver/src/: ht32f1xxxx_i2c.c ht32f1xxxx_aes.c ht32f1xxxx_usbd.c ht32f1xxxx_wdt.c ht32f1xxxx_bftm.c ht32f1xxxx_rstcu.c ht32f1xxxx_pdma.c ht32f1xxxx_flash.c ht32f1xxxx_ckcu.c ht32f1xxxx_cmp.c ht32f1xxxx_crc.c ht32f1xxxx_mctm.c ht32f1xxxx_ebi.c ht32f1xxxx_sdio.c ht32f1xxxx_i2s.c ht32f2xxxx_csif.c ht32_cm3_misc.c ht32f1xxxx_rtc.c ht32f1xxxx_spi.c ht32f1xxxx_gpio.c ht32f1xxxx_exti.c ht32f1xxxx_usart.c ht32f1xxxx_sci.c ht32f1xxxx_adc.c ht32f1xxxx_pwrcu.c ht32f1xxxx_tm.c
    ../libraries/HT32_STD_1xxxx_FWLib/library/Device/Holtek/HT32F1xxxx/Source/: system_ht32f1xxxx_02.c
