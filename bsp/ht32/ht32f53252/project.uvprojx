# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: HT32F53252 Holtek
  pack: Holtek.HT32_DFP.1.0.55
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x00000000-0x0001FBFF) CLOCK(8000000) CPUTYPE("Cortex-M0+")
  output: rt-thread
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: RT_USING_LIBC, __RTTHREAD__, __CLK_TCK=RT_TICK_PER_SECOND, RT_USING_ARMLIBC, USE_HT32F53252_SK, USE_HT32F53242_52, USE_MEM_HT32F53252, USE_HT32_DRIVER, __STDC_LIMIT_MACROS
  c include: applications;board\inc;..\..\..\libcpu\arm\common;..\..\..\components\drivers\include;..\libraries\ht32_drivers;..\..\..\components\libc\posix\io\poll;..\libraries\usbd_library\inc;..\libraries\HT32_STD_5xxxx_FWLib\library\CMSIS\Include;..\..\..\libcpu\arm\cortex-m0;..\libraries\HT32_STD_5xxxx_FWLib\library\HT32F5xxxx_Driver\inc;..\..\..\components\libc\posix\io\epoll;..\..\..\components\libc\posix\io\eventfd;..\..\..\include;..\..\..\components\libc\compilers\common\extension\fcntl\octal;..\..\..\components\finsh;..\..\..\components\drivers\include;.;..\libraries\HT32_STD_5xxxx_FWLib\library\Device\Holtek\HT32F5xxxx\Include;..\..\..\components\drivers\include;..\..\..\components\libc\posix\ipc;..\..\..\components\libc\compilers\common\extension;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\libc\compilers\common\include
  asm define: USE_HT32_CHIP=28
  memory RVCT4: ROM 0x0 size 0x1fc00
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Applications
    applications/: main.c test.c
  group Compiler
    ../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group DeviceDrivers
    ../../../components/drivers/can/: can.c
    ../../../components/drivers/core/: device.c
    ../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/pin/: pin.c
    ../../../components/drivers/serial/: serial.c
    ../../../components/drivers/watchdog/: watchdog.c
  group Drivers
    board/src/: board.c ht32_msp.c
    ../libraries/HT32_STD_5xxxx_FWLib/library/Device/Holtek/HT32F5xxxx/Source/ARM/: startup_ht32f5xxxx_15.s
    ../libraries/ht32_drivers/: drv_can.c drv_common.c drv_gpio.c drv_usart.c
  group Finsh
    ../../../components/finsh/: msh.c shell.c msh_parse.c cmd.c
  group Kernel
    ../../../src/: clock.c components.c cpu_up.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
    ../../../src/klibc/: kstdio.c kstring.c
  group libcpu
    ../../../libcpu/arm/common/: div0.c showmem.c
    ../../../libcpu/arm/cortex-m0/: context_rvds.S cpuport.c
  group Libraries
    ../libraries/HT32_STD_5xxxx_FWLib/library/HT32F5xxxx_Driver/src/: ht32f5xxxx_adc.c ht32f5xxxx_ledc.c ht32_cm0plus_misc.c ht32f5xxxx_rtc.c ht32f5xxxx_gpio.c ht32f5xxxx_exti.c ht32f5xxxx_pdma.c ht32f5xxxx_rstcu.c ht32f5xxxx_crc.c ht32f5xxxx_bftm.c ht32f5xxxx_ckcu.c ht32f5xxxx_pwrcu.c ht32f5xxxx_wdt.c ht32f5xxxx_tm.c ht32f5xxxx_mctm.c ht32f5xxxx_i2c.c ht32f5xxxx_cmp.c ht32f5xxxx_ebi.c ht32f5xxxx_can.c ht32f5xxxx_usart.c ht32f5xxxx_div.c ht32f5xxxx_spi.c ht32f5xxxx_flash.c
    ../libraries/HT32_STD_5xxxx_FWLib/library/Device/Holtek/HT32F5xxxx/Source/: system_ht32f5xxxx_15.c
